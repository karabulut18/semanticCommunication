options:
  parameters:
    author: Barry Duggan
    description: packet transmit
    generate_options: qt_gui
    id: pkt_xmt
    output_language: python
    title: pkt_xmt
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '20000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: '1.040'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: InFile
  id: parameter
  parameters:
    label: File Name
    type: str
    value: default
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: usrp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    Pkt_len: '60'
    _source_code: |
      """
      Embedded Python Block: ZMQ data to Tagged Stream
      """

      import numpy as np
      from gnuradio import gr
      import time
      import pmt
      import os.path
      import sys
      import base64

      """
      State definitions
          0   idle (wait for the message)
          1   send preamble
          2   send data
          3   send post filler
      """

      class blk(gr.sync_block):
          def __init__(self, Pkt_len=52, debug_active=False):
              gr.sync_block.__init__(
                  self,
                  name='ZMQ Data to Tagged Stream',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8])
              self.Pkt_len    = Pkt_len
              self.state      = 0 # idle state
              self._debug     = debug_active
              self.state = 0

              self.preamble = [37,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,93]
              # print (self.c_len)
              self.filler = [37,85,85,85, 35,69,79,70, 85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,93]
              self.buffer = []


          def work(self, input_items, output_items):
              in_signal   = input_items[0]
              out_signal  = output_items[0]

              available_space = len(out_signal)
              total_written = 0

              self.buffer.extend(in_signal)

              while available_space > 0:
                  if self.state == 0:  # Idle
                      if len(self.buffer) >= self.pkt_len:
                          self.state = 1  # Move to preamble
                      else:
                          break

                  elif self.state == 1:  # Send Preamble
                      to_write = min(len(self.preamble), available_space)
                      output_items[0][:to_write] = self.preamble[:to_write]
                      total_written   += to_write
                      available_space -= to_write
                      self.indx       += to_write

                      if to_write < len(self.preamble):
                          self.preamble = self.preamble[to_write:]  # Send remaining preamble next
                      else:
                          self.state = 2  # Move to data
                      break

                  elif self.state == 2:  # Send Data
                      if self.data_index >= len(self.current_data):
                          self.state = 3  # Data complete, move to postamble
                          break

                      chunk = self.current_data[self.data_index:self.data_index + self.pkt_len]
                      to_write = min(len(chunk), available_space)
                      output_items[0][:to_write] = chunk[:to_write]
                      self.add_item_tag(0, self.indx, pmt.intern("packet_len"), pmt.from_long(to_write))
                      self.data_index += to_write
                      total_written   += to_write
                      available_space -= to_write
                      self.indx       += to_write

                      if self.data_index >= len(self.current_data):
                          self.state = 3  # All data sent
                      break

                  elif self.state == 3:  # Send Postamble
                      to_write = min(len(self.postamble), available_space)
                      output_items[0][:to_write] = self.postamble[:to_write]
                      total_written   += to_writenn
                      available_space -= to_write
                      self.indx       += to_write

                      if to_write < len(self.postamble):
                          self.postamble = self.postamble[to_write:]  # Send remaining postamble next
                      else:
                          self.state = 0  # Back to idle
                      break

              return total_written
    comment: |-
      Filename is specified on the command line, e.g.:
      python3 pkt_xmt.py --InFile="../gr-logo.png"
    debug_active: 'False'
  states: {}
- name: fft_filter_xxx_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 1.0/((usrp_rate/samp_rate)*rs_ratio)
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,3
    gui_hint: 1,0,1,3
    label1: ''
    name: Transmit data
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49203
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49209
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_repack_bits_bb_0_0, '0', blocks_uchar_to_float_0_0_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0, '0']
- [blocks_throttle2_0_0, '0', zeromq_pub_sink_0, '0']
- [blocks_uchar_to_float_0_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', fft_filter_xxx_0_0_0, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [epy_block_0, '0', digital_crc32_bb_0, '0']
- [fft_filter_xxx_0_0_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', blocks_throttle2_0_0, '0']
- [virtual_source_0, '0', blocks_repack_bits_bb_0_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [zeromq_sub_source_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
