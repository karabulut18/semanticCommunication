options:
  parameters:
    author: Barry Duggan
    description: packet transmit
    generate_options: qt_gui
    id: pkt_xmt
    output_language: python
    title: pkt_xmt
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '20000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: rs_ratio
  id: variable
  parameters:
    value: '1.040'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: InFile
  id: parameter
  parameters:
    label: File Name
    type: str
    value: default
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: MSB
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: usrp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    Pkt_len: '1500'
    _source_code: "\"\"\"\nEmbedded Python Block: Byte Stream to Tagged Stream\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nfrom collections import deque\nfrom typing import Deque\n\n\"\"\"\nState Definitions:\n    0: Idle\n    1: Send Preamble\n    2: Send Data\n    3: Send Postamble\n\"\"\"\n\nclass blk(gr.sync_block):\n    def __init__(self, Pkt_len=52):\n        gr.sync_block.__init__(\n            self,\n            name=\"EPB: Byte Stream to Tagged Stream\",\n            in_sig=[np.uint8],  # Input stream of bytes\n            out_sig=[np.uint8]  # Output stream of bytes\n        )\n\n        self.Pkt_len    = Pkt_len\n        self.state      = 0  # Start in idle state\n        self.indx       = 0  # Absolute index for tagging\n\n        # Preamble and Postamble definitions\n        self.preamble       = np.array([37,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,93], dtype=np.uint8)\n        self.preamble_len   = len(self.preamble)\n        self.postamble      = np.array([37,85,85,85, 35,69,79,70, 85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85, 85,85,85,93], dtype=np.uint8)\n        self.postamble_len  = len(self.postamble)\n\n        self.pre_count      = 0\n        self.buffer         = bytearray()\n\n        # Internal buffer to hold incoming data\n        self.message_queue: Deque[bytearray] = deque()\n\n    def work(self, input_items, output_items):\n        in_stream = input_items[0]\n        out_stream = output_items[0]\n\n        available_space = len(out_stream)  # Remaining space in the output buffer\n        total_written = 0  # Track how much data is written in this call\n\n        # Add incoming data to the internal buffer\n        if len(in_stream > 0):\n            self.message_queue.append(bytearray(in_stream))\n\n        while available_space > 0:\n            if self.state == 0:  # Idle\n                # If there's data in the buffer, move to the preamble state\n\n                if self.message_queue or self.buffer != b'':\n                    self.state = 1\n                else:\n                    break\n\n            elif self.state == 1:  # Send Preamble\n                to_write = min(self.preamble_len, available_space)\n                # Tag for the preamble\n                self.add_item_tag(0, self.indx, pmt.intern(\"packet_len\"), pmt.from_long(to_write))\n                out_stream[total_written:total_written + to_write] = self.preamble[:to_write]\n                self.indx += to_write\n                total_written += to_write\n                available_space -= to_write\n\n                # Transition to data if the preamble is fully sent\n                self.pre_count +=1\n                if(self.pre_count > 16):\n                    self.pre_count = 0\n                    self.state = 2\n            elif self.state == 2:  # Send Data\n                if self.message_queue:\n                    self.buffer = self.message_queue.popleft()\n                elif self.buffer == b'':\n                    # No more data in the buffer, move to postamble\n                    self.state = 3\n                    continue\n\n                to_write = min(len(self.buffer), self.Pkt_len)\n                to_write = min(to_write, available_space)\n                # Take a chunk of data from the buffer\n\n                data_chunk = self.buffer[:to_write]\n                if not to_write == len(self.buffer):\n                    self.buffer = self.buffer[to_write:]# Remove processed data\n                else:\n                    self.buffer = bytearray()\n\n                # Tag for the data chunk\n                self.add_item_tag(0, self.indx, pmt.intern(\"packet_len\"), pmt.from_long(to_write))\n                out_stream[total_written:total_written + to_write] = data_chunk[:to_write]\n                self.indx       += to_write\n                total_written   += to_write\n                available_space -= to_write\n\n            elif self.state == 3:  # Send Postamble\n                to_write = min(self.postamble_len, available_space)\n\n                # Tag for the postamble\n                self.add_item_tag(0, self.indx, pmt.intern(\"packet_len\"), pmt.from_long(to_write))\n                out_stream[total_written:total_written + to_write] = self.postamble[:to_write]\n                self.indx += to_write\n                total_written += to_write\n                available_space -= to_write\n\n                # Transition back to idle after sending the postamble\n                self.pre_count +=1\n                if(self.pre_count > 4):\n                    self.pre_count = 0\n                    self.state = 0\n\n        return total_written\n\n"
    comment: |-
      add tags "packet_len" to byte stream
      test
  states: {}
- name: fft_filter_xxx_0_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: low_pass_filter_taps
    type: ccc
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: 1.0/((usrp_rate/samp_rate)*rs_ratio)
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,3
    gui_hint: 1,0,1,3
    label1: ''
    name: Transmit data
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: t1
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: t1
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49203
    comment: USRP sample rate = 768kHz
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49209
    timeout: '100'
    type: byte
  states: {}

connections:
- [blocks_repack_bits_bb_0_0, '0', blocks_uchar_to_float_0_0_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_0_0, '0']
- [blocks_throttle2_0_0, '0', zeromq_pub_sink_0, '0']
- [blocks_uchar_to_float_0_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [digital_constellation_modulator_0, '0', fft_filter_xxx_0_0_0, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [epy_block_0, '0', digital_crc32_bb_0, '0']
- [fft_filter_xxx_0_0_0, '0', mmse_resampler_xx_0, '0']
- [mmse_resampler_xx_0, '0', blocks_throttle2_0_0, '0']
- [virtual_source_0, '0', blocks_repack_bits_bb_0_0, '0']
- [virtual_source_0, '0', digital_constellation_modulator_0, '0']
- [zeromq_sub_source_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
